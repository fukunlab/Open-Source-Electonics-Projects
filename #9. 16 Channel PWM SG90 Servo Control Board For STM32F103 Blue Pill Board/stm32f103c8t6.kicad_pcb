# Repository fukunlab/Open-Source-Electonics-Projects

File README.md:

# Open-Source-Electonics-Projects
CONTACT TO ME BY EMAILL:info@fukunlab.com

## KiCad design #9. 16 Channel PWM SG90 Servo Control Board For STM32F103 Blue Pill Board/stm32f103c8t6.kicad_pcb

Parts:
J1, J2, J5: Conn_01x16; PinHeader_1x16_P2.54mm_Vertical
J3, J4: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J7: Conn_01x02; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal

Connections:
3.3VD: J3.1, J4.18
5V: J2.1, J2.2, J2.3, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.11, J2.12, J2.13, J2.14, J2.15, J2.16, J3.3, J7.2
GND: J3.2, J4.19, J4.20, J5.1, J5.2, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J5.9, J5.10, J5.11, J5.12, J5.13, J5.14, J5.15, J5.16, J7.1
NRST: J4.17
PA0: J1.16, J4.5
PA1: J1.15, J4.6
PA2: J1.14, J4.7
PA3: J1.13, J4.8
PA4: J4.9
PA5: J4.10
PA6: J1.8, J4.11
PA7: J1.7, J4.12
PA8: J1.1, J3.16
PA9: J1.2, J3.15
PA10: J1.3, J3.14
PA15: J3.11
PB0: J1.6, J4.13
PB1: J1.5, J4.14
PB3: J3.10
PB4: J3.9
PB5: J3.8
PB6: J1.9, J3.7
PB7: J1.10, J3.6
PB8: J1.11, J3.5
PB9: J1.12, J3.4
PB10: J4.15
PB11: J4.16
PB12: J3.20
PB13: J3.19
PB14: J3.18
PB15: J3.17
PC13: J4.2
PC14: J4.3
PC15: J4.4
USB_DM: J1.4, J3.13
USB_DP: J3.12
Vbat: J4.1

Board: 2 copper layers, 22.9 x 53.3 mm, 6 parts (4 on the bottom side), 19 nets.

## KiCad design #7. LIGHT COMPATIBLE OPENMV/1.light.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
D1: SDM03U40-7/30mA; D_SOD-523
D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_PLCC_2835
J1, J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
L1: 4.7H/1.8A; L_1210_3225Metric
R1: 3.4R; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
U1: SOT-353_SC-70-5

Connections:
/PWM_CTRL: J1.7, R2.2, U1.4 (CTRL)
GND: C1.2, C2.2, J2.8, R1.1, R2.1, U1.2 (GND)
unnamed: D1.1 (A), L1.2, U1.1 (SW)
unnamed: C2.1, D1.2 (K), D5.2 (A)
unnamed: D2.2 (A), D3.1 (K)
unnamed: D2.1 (K), D8.2 (A)
unnamed: D3.2 (A), D4.1 (K)
unnamed: D4.2 (A), D5.1 (K)
unnamed: D6.2 (A), D7.1 (K)
unnamed: D7.2 (A), D8.1 (K)
unnamed: D9.1 (K), R1.2, U1.3 (FB)
unnamed: D6.1 (K), D10.2 (A)
unnamed: D9.2 (A), D10.1 (K)
VCC: C1.1, J2.7, L1.1, U1.5 (VIN)

Notes on the sheet:
I=204/3.4=60mA NSR0240HT1G/250mA I=204/6.8=30mA SDM03U40-7/30mA

Board: 2 copper layers, 35.6 x 26.0 mm, 18 parts (2 on the bottom side), 14 nets.

## KiCad design #6. 1.8TFTLCD COMPATIBLE OPENMV/1.8TFTLCD_7735.kicad_pcb

Parts:
C1: 4.7uF; C_0603_1608Metric
C2: 0.1uF; C_0603_1608Metric
J1, J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical_SMD_Pin1Right
J3: Conn_01x02; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
L1: FB1; L_0603_1608Metric
Q1: 7002; SOT-23
R1: 2.2K; R_0603_1608Metric
R2, R4: 10K; R_0603_1608Metric
R3: 10R; R_0603_1608Metric
U1: LCD_TFT18004_min1mm

Connections:
+3V3: C1.1, C2.1, J1.8, L1.1, R2.2, R4.2, U1.3 (LED+), U1.10 (VCC)
/CS: J1.4, R4.1, U1.11 (CS)
/LED: J3.2, R1.1
/RS: J2.5, U1.6 (A0)
/RST: J2.6, U1.5 (RESET)
/SCK: J1.3, U1.8 (SCK)
/SDI: J1.1, U1.7 (SDA)
GND: C1.2, C2.2, J2.8, Q1.2 (S), U1.1 (GND), U1.4 (GND), U1.12 (GND), U1.17 (GND), U1.18 (GND)
unnamed: J1.7, J3.1
unnamed: L1.2, U1.9 (VCC)
unnamed: Q1.3 (D), R3.1
unnamed: Q1.1 (G), R1.2, R2.1
unnamed: R3.2, U1.2 (LED-)

Board: 2 copper layers, 39.0 x 48.0 mm, 12 parts (11 on the bottom side), 13 nets.

## KiCad design #3. MPU6050/MPU6050.kicad_pcb

Parts:
C5, C29: 1uF/10V; C_0603_1608Metric
C34, C37: 0.1uf; C_0603_1608Metric
C35: 2.2nf; C_0603_1608Metric
C36: 10nf; C_0603_1608Metric
D1: LED; D_0603_1608Metric
J1, J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J3: Conn_01x04; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
R40, R41: 4.7K; R_0603_1608Metric
R42, R43: 0; R_0603_1608Metric
R44: 1k; R_0603_1608Metric
U1: ME6211C33M5; SOT-23-5
U12: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm

Connections:
/AD0: J2.1, U12.9 (AD0)
/CLK_IN: J2.5, R43.2, U12.1 (CLKIN)
/FSYNC_IN: J2.2, R42.2, U12.11 (FSYNC)
/INT: J1.4, U12.12 (INT)
/SCL: J1.6, J3.4, R41.2, U12.23 (SCL)
/SCL_EXT: J2.3, U12.7 (AUX_CL)
/SDA: J1.5, J3.3, R40.2, U12.24 (SDA)
/SDA_EXT: J2.4, U12.6 (AUX_DA)
GND: C5.2, C29.2, C34.2, C35.2, C36.1, C37.2, J1.3, J2.6, J3.2, R42.1, R43.1, R44.1, U1.2 (V_{SS}), U12.18 (GND)
unnamed: D1.1 (K), R44.2
unnamed: C35.1, U12.20 (CPOUT)
unnamed: C37.1, U12.10 (REGOUT)
VCC: C5.1, J1.1, J3.1, U1.1 (V_{IN}), U1.3 (CE)
VCC_3V3: C29.1, C34.1, C36.2, D1.2 (A), J1.2, R40.1, R41.1, U1.5 (V_{OUT}), U12.8 (VLOGIC), U12.13 (VDD)

Notes on the sheet:
AD0:从机地址设置引脚 : 1.接地或悬空时, 地址为0x68； 2.接VCC时，地址为0x69

Board: 2 copper layers, 20.0 x 26.0 mm, 17 parts (0 on the bottom side), 14 nets.

## KiCad design #5. STM32H743VIT6 CAMERA COMPATIBLE OPENMV/connector.kicad_pcb

Parts:
J1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical_SMD
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
J3: USB_OTG; USB_Micro-B_Molex-105133-0001
J4: Conn_01x02; Molex_Micro-Latch_53253-0270_1x02_P2.00mm_Vertical
J5: Conn_02x12_Top_Bottom; SGDBM-05-24P-H40_hand

Connections:
/BOOT0: J1.4, J5.13
/DAC: J1.13, J5.14
/DCMI_FSIN: J1.6, J5.16
/FS_DM: J3.2 (D-), J5.19
/FS_DP: J3.3 (D+), J5.20
/I2C2_SCL: J1.9, J5.12
/I2C2_SDA: J1.11, J5.11
/NRST: J1.2, J2.4, J5.17
/SPI2_MISO: J1.3, J5.8
/SPI2_MOSI: J1.1, J5.7
/SPI2_NSS: J1.7, J5.10
/SPI2_SCLK: J1.5, J5.9
/SPI3_SCLK/TRACESWO: J2.1, J5.15
/SWCLK: J2.2, J5.18
/SWDIO: J2.3, J5.21
/TIM4_CH1: J1.12, J5.24
/TIM4_CH2: J1.10, J5.23
/TIM4_CH3: J1.8, J5.22
/USB_V: J3.1 (VBUS), J5.2
GND: J1.16, J2.5, J3.5 (GND), J3.6 (Shield), J4.2, J5.1, J5.5
VCC: J1.15, J5.4
VIN: J1.14, J4.1, J5.3

Board: 2 copper layers, 26.0 x 26.0 mm, 5 parts (1 on the bottom side), 22 nets.

## KiCad design #2. DRV8871/DRV8871_Single.kicad_pcb

Parts:
C1: 330uF; CP_Elec_10x10.5
C2: 0.1uf; C_0805_2012Metric
J1: Conn_01x02; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
M1: Motor_DC; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal
R1: 30k; R_0603_1608Metric
TP1: TestPoint_2Pole; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
U2: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
FL1: J2.2, U2.3 (IN1)
FL2: J2.1, U2.2 (IN2)
GND: C1.2, C2.2, J1.2, J2.4, R1.2, TP1.1, U2.1 (GND), U2.7 (GND), U2.9 (GND)
unnamed: M1.1 (+), U2.8 (OUT2)
unnamed: M1.2 (-), U2.6 (OUT1)
unnamed: R1.1, TP1.2, U2.4 (ILIM)
Vin: C1.1, C2.1, J1.1, J2.3, U2.5 (VM)

Notes on the sheet:
I=V_VERF/(10*R_ISEN)

Board: 2 copper layers, 25.0 x 30.0 mm, 8 parts (0 on the bottom side), 7 nets.

## KiCad design #5. STM32H743VIT6 CAMERA COMPATIBLE OPENMV/OV7725.kicad_pcb

Parts:
C1: 47uF; C_0805_2012Metric
C2, C5, C6, C7: 0.1uF; C_0603_1608Metric
C3: 22uF; C_0603_1608Metric
C4: 4,7uF; C_0603_1608Metric
D1, D2: VSMY12850; LED_1206_3216Metric
J1: Conn_02x18_Top_Bottom; SGDBM-05-36P-H40_hand
Q1: BSS138; SOT-23
R1: 4.7R; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R3: 220R; R_0603_1608Metric
R4: 10K; R_0603_1608Metric
R5: 10R; R_0603_1608Metric
U1: JY20xx
U2: OV7725

Connections:
/DCMI_CLK: J1.6, U2.F3 (XCLK)
/DCMI_D0: J1.24, U2.F5 (D2)
/DCMI_D1: J1.23, U2.F2 (D3)
/DCMI_D2: J1.32, U2.D6 (D4)
/DCMI_D3: J1.33, U2.D1 (D5)
/DCMI_D4: J1.16, U2.E6 (D6)
/DCMI_D5: J1.28, U2.E1 (D7)
/DCMI_D6: J1.17, U2.F6 (D8)
/DCMI_D7: J1.18, U2.F1 (D9)
/DCMI_FSIN: J1.21, R2.1, U2.A4 (FSIN)
/DCMI_HSYNC: J1.36, U2.B6 (HSYNC)
/DCMI_PCLK: J1.34, U2.E4 (PCLK)
/DCMI_PWDN: J1.25, U2.C1 (PWDN)
/DCMI_RST: J1.22, U2.A2 (RESET)
/DCMI_VSYNC: J1.29, U2.C6 (VSYNC)
/I2C1_SCL: J1.30, U2.A5 (SCL)
/I2C1_SDA: J1.31, U2.B5 (SDA)
/LED_IR: J1.15, R3.1
/RSVD1: J1.14
/RSVD2: J1.13
/RSVD3: J1.12
/RSVD4: J1.11
/RSVD5: J1.3
/RSVD6: J1.4
/SPI3_MISO: J1.26
/SPI3_MOSI: J1.27
/SPI3_SCLK/TRACESWO: J1.20
/SPI3_SSEL: J1.19
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.7, J1.8, J1.9, J1.35, Q1.2 (S), R2.2, R4.2, U2.B1 (ADGND), U2.B4 (AGND), U2.F4 (DOGND)
unnamed: D1.2 (A), D2.1 (K)
unnamed: D1.1 (K), R5.2
unnamed: Q1.3 (D), R5.1
unnamed: Q1.1 (G), R3.2, R4.1
unnamed: C4.1, R1.2, U2.A1 (AVDD), U2.B3 (ADVDD)
unnamed: C5.1, U2.E3 (DVDD)
unnamed: C6.1, U2.A3 (VREFH)
unnamed: C7.1, U2.B2 (VREFN)
VCC: C1.1, C2.1, C3.1, D2.2 (A), J1.1, J1.5, J1.10, U2.E5 (DOVDD)
VDDA: J1.2, R1.1

Notes on the sheet:
0603 current?
可能亮度不够，可考虑设计一个并联冗余
xie dui jieo?

Board: 2 copper layers, 26.0 x 26.0 mm, 18 parts (6 on the bottom side), 29 nets.

## KiCad design #4. VL53L0X/VL53L0X.kicad_pcb

Parts:
C8, C29: 1uF/10V; C_0603_1608Metric
C11: 10uF; C_0603_1608Metric
C12: 100nF; C_0603_1608Metric
D1: LED; D_0603_1608Metric
J1: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J3: Conn_01x04; JST_SH_BM04B-SRSS-TB_1x04-1MP_P1.00mm_Vertical
R6, R7, R8, R9: 4.7K; R_0603_1608Metric
R44: 1k; R_0603_1608Metric
U2: VL53L0CXV0FY1; ST_VL53L1x
U5: ME6211C33M5; SOT-23-5

Connections:
/GPIO1: J1.6, R6.2, U2.7 (GPIO1)
/SCL: J1.4, J3.4, R9.2, U2.10 (SCL)
/SDA: J1.3, J3.3, R8.2, U2.9 (SDA)
/XSHUT: J1.5, R7.2, U2.5 (XSHUT)
GND: C8.2, C11.2, C12.2, C29.2, J1.2, J3.2, R44.1, U2.2 (AVSSVCSEL), U2.3 (GND), U2.4 (GND), U2.6 (GND), U2.12 (GND), U5.2 (V_{SS})
unnamed: D1.1 (K), R44.2
VCC: C8.1, J1.1, J3.1, U5.1 (V_{IN}), U5.3 (CE)
VCC_3V3: C11.1, C12.1, C29.1, D1.2 (A), R6.1, R7.1, R8.1, R9.1, U2.1 (AVDDVCSEL), U2.11 (AVDD), U5.5 (V_{OUT})

Board: 2 copper layers, 20.0 x 26.0 mm, 14 parts (0 on the bottom side), 8 nets.

## Commit log

2025-10-15 V1.0
