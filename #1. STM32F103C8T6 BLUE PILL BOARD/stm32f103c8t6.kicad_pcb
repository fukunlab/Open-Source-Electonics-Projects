# Repository fukunlab/Open-Source-Electonics-Projects

## KiCad design #1. STM32F103C8T6 BLUE PILL BOARD/stm32f103c8t6.kicad_pcb

Parts:
C5, C10, C11, C14, C15, C16, C17: 0.1uF/50V(10%); C_0603_1608Metric
C6, C7, C8, C9: 22pF; C_0603_1608Metric
C12, C13: 1uF; C_0603_1608Metric
D1: PWR; D_0603_1608Metric
D2: PWM; D_0603_1608Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J3, J4: Conn_01x20; PinHeader_1x20_P2.54mm_Vertical
J5: debug; PinHeader_1x04_P2.54mm_Vertical
R3: 1.5k; R_0603_1608Metric
R4, R5: 1k; R_0603_1608Metric
R6, R7, R8: 10K(1%); R_0603_1608Metric
R9, R10: 5.1k; R_0603_1608Metric
SW1, SW2, SW3: TS-1088R-02026; SW_SPST_B3U-1000P
U1: ME6211C33M5; SOT-23-5
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
X1: Crystal_Generic; Crystal_SMD_3225-4Pin_3.2x2.5mm
X2: Crystal_Generic; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
3.3VD: C10.2, C11.2, C13.1, C14.1, C15.1, C16.1, C17.1, D1.2 (A), D2.2 (A), J3.1, J4.18, J5.3, R6.2, SW2.1, SW3.1, U1.5 (V_{OUT}), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD)
5V: C12.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J3.3, U1.1 (V_{IN}), U1.3 (CE)
BOOT0: C10.1, R7.2, SW2.2, U3.44 (BOOT0)
BOOT1: C11.1, R8.2, SW3.2, U3.20 (PB2)
GND: C5.2, C6.1, C7.1, C8.1, C9.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.2, J4.19, J4.20, J5.4, R4.2, R7.1, R8.1, R9.1, R10.1, SW1.1, U1.2 (V_{SS}), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), X1.2, X1.4
NRST: C5.1, J4.17, R6.1, SW1.2, U3.7 (NRST)
unnamed: D1.1 (K), R4.1
unnamed: D2.1 (K), R5.1
unnamed: J1.A5 (CC1), R9.2
unnamed: J1.B5 (CC2), R10.2
PA0: J4.5, U3.10 (PA0)
PA1: J4.6, U3.11 (PA1)
PA2: J4.7, U3.12 (PA2)
PA3: J4.8, U3.13 (PA3)
PA4: J4.9, U3.14 (PA4)
PA5: J4.10, U3.15 (PA5)
PA6: J4.11, U3.16 (PA6)
PA7: J4.12, U3.17 (PA7)
PA8: J3.16, U3.29 (PA8)
PA9: J3.15, U3.30 (PA9)
PA10: J3.14, U3.31 (PA10)
PA15: J3.11, U3.38 (PA15)
PB0: J4.13, U3.18 (PB0)
PB1: J4.14, U3.19 (PB1)
PB3: J3.10, U3.39 (PB3)
PB4: J3.9, U3.40 (PB4)
PB5: J3.8, U3.41 (PB5)
PB6: J3.7, U3.42 (PB6)
PB7: J3.6, U3.43 (PB7)
PB8: J3.5, U3.45 (PB8)
PB9: J3.4, U3.46 (PB9)
PB10: J4.15, U3.21 (PB10)
PB11: J4.16, U3.22 (PB11)
PB12: J3.20, U3.25 (PB12)
PB13: J3.19, U3.26 (PB13)
PB14: J3.18, U3.27 (PB14)
PB15: J3.17, R3.1, U3.28 (PB15)
PC13: J4.2, R5.2, U3.2 (PC13)
PC14: C8.2, J4.3, U3.3 (PC14), X2.1
PC15: C9.2, J4.4, U3.4 (PC15), X2.2
PD0: C6.2, U3.5 (PD0), X1.3
PD1: C7.2, U3.6 (PD1), X1.1
SWCLK: J5.1, U3.37 (PA14)
SWDIO: J5.2, U3.34 (PA13)
USB_DM: J1.A7 (D-), J1.B7 (D-), J3.13, U3.32 (PA11)
USB_DP: J1.A6 (D+), J1.B6 (D+), J3.12, R3.2, U3.33 (PA12)
Vbat: J4.1, U3.1 (VBAT)

Board: 2 copper layers, 22.9 x 53.3 mm, 34 parts (2 on the bottom side), 47 nets.

## KiCad design #5. STM32H743VIT6 CAMERA COMPATIBLE OPENMV/STM32H743VIT6_MINI.kicad_pcb

Parts:
C1, C2: 2.2uF; C_0603_1608Metric
C3, C4, C5, C6, C12: 0.1uF; C_0603_1608Metric
C7, C8: 12pf; C_0603_1608Metric
C9, C18, C19: 47uf; C_0805_2012Metric
C10, C11: 1uF; C_0603_1608Metric
C13, C14: 1UF; C_0603_1608Metric
C15: 0.1uf; C_0603_1608Metric
C16, C17: 22uF; C_0603_1608Metric
D1: SDM2U20SD3-7; D_SOD-323
D2: LED_RABG; LED_RGB_1210
J1: TF Card
J3: Conn_02x12_Top_Bottom; SGDBF-05-24P-H40_hand
J4: Conn_02x18_Top_Bottom; SGDBF-05-36P-H40_hand
L1, L3: MPZ1608S181ATAH0; L_0603_1608Metric
L2: 4.7uH/1.4A; L_0603_1608Metric
Q1: SOT-23-3
R3: 10k; R_0603_1608Metric
R6, R7: 4.7k; R_0603_1608Metric
R11, R12, R13: 220R; R_0603_1608Metric
RN1, RN2: 10k; R_Array_Convex_4x0603
U1: STM32H743VITx; LQFP-100_14x14mm_P0.5mm
U2: ME6211C33M5; SOT-23-5
U4: PAM2305AAB330; TSOT-23-5
Y1: 12M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
/BOOT0: J3.24, RN1.5 (R4.2), U1.94 (BOOT0)
/DAC: J3.23, U1.29 (PA5)
/DCMI_CLK: J4.24, U1.67 (PA8)
/DCMI_D0: J4.6, U1.63 (PC6)
/DCMI_D1: J4.5, U1.64 (PC7)
/DCMI_D2: J4.14, U1.97 (PE0)
/DCMI_D3: J4.15, U1.98 (PE1)
/DCMI_D4: J4.34, U1.3 (PE4)
/DCMI_D5: J4.10, U1.92 (PB6)
/DCMI_D6: J4.35, U1.4 (PE5)
/DCMI_D7: J4.36, U1.5 (PE6)
/DCMI_FSIN: J3.21, J4.3
/DCMI_HSYNC: J4.18, U1.28 (PA4)
/DCMI_PCLK: J4.16, U1.30 (PA6)
/DCMI_PWDN: J4.7, U1.88 (PD7)
/DCMI_RST: J4.4, U1.69 (PA10)
/DCMI_VSYNC: J4.11, U1.93 (PB7)
/FREX: U1.56 (PD9)
/FS_DM: J3.18, U1.70 (PA11)
/FS_DP: J3.17, U1.71 (PA12)
/FXPST: U1.55 (PD8)
/GPIO1: U1.84 (PD3)
/GPIO2: U1.85 (PD4)
/GPIO3: U1.82 (PD1)
/I2C1_SCL: J4.12, R6.1, U1.95 (PB8)
/I2C1_SDA: J4.13, R7.1, U1.96 (PB9)
/I2C2_SCL: J3.1, U1.46 (PB10)
/I2C2_SDA: J3.2, U1.47 (PB11)
/LED_B: R13.2, U1.17 (PC2_C)
/LED_G: R12.2, U1.16 (PC1)
/LED_IR: J4.33, U1.1 (PE2)
/LED_R: R11.2, U1.15 (PC0)
/NRST: C11.2, J3.20, RN1.6 (R3.2), U1.14 (NRST)
/RSVD1: J4.32
/RSVD2: J4.31
/RSVD3: J4.30
/RSVD4: J4.29
/RSVD6: J4.22
/SDIO_CLK: J1.5 (CLK), U1.80 (PC12)
/SDIO_CMD: J1.3 (CMD), RN2.7 (R2.2), U1.83 (PD2)
/SDIO_D0: J1.7 (DAT0), RN2.8 (R1.2), U1.65 (PC8)
/SDIO_D1: J1.8 (DAT1), RN1.8 (R1.2), U1.66 (PC9)
/SDIO_D2: J1.1 (DAT2), RN2.5 (R4.2), U1.78 (PC10)
/SDIO_D3: J1.2 (DAT3), RN2.6 (R3.2), U1.79 (PC11)
/SD_CD: J1.9 (CD), RN1.7 (R2.2), U1.81 (PD0)
/SPI2_MISO: J3.5, U1.53 (PB14)
/SPI2_MOSI: J3.6, U1.54 (PB15)
/SPI2_NSS: J3.3, U1.51 (PB12)
/SPI2_SCLK: J3.4, U1.52 (PB13)
/SPI3_MISO: J4.8, U1.90 (PB4)
/SPI3_MOSI: J4.9, U1.91 (PB5)
/SPI3_SCLK/TRACESWO: J3.22, J4.2, U1.89 (PB3)
/SPI3_SSEL: J4.1, U1.77 (PA15)
/SWCLK: J3.19, U1.76 (PA14)
/SWDIO: J3.16, U1.72 (PA13)
/TIM4_CH1: J3.13, U1.59 (PD12)
/TIM4_CH2: J3.14, U1.60 (PD13)
/TIM4_CH3: J3.15, U1.61 (PD14)
/UART2_RX: U1.87 (PD6)
/UART2_TX: U1.86 (PD5)
/USB_V: J3.11, L3.1
/VDVR: C10.2, C12.1, L1.1, U1.20 (VREF+), U1.21 (VDDA)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, C10.1, C11.1, C12.2, C13.1, C14.1, C15.2, C16.1, C17.1, C18.2, C19.2, J1.6 (VSS), J1.Shield, J3.8, J3.12, J4.17, J4.25, J4.26, J4.27, R3.1, RN1.4 (R4.1), U1.10 (VSS), U1.19 (VSSA), U1.26 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U2.2 (V_{SS}), U4.2 (GND), Y1.2, Y1.4
unnamed: C1.1, U1.48 (VCAP)
unnamed: C2.1, U1.73 (VCAP)
unnamed: D2.3 (BK), R11.1
unnamed: D2.4 (GK), R12.1
unnamed: D2.1 (RK), R13.1
unnamed: C7.1, U1.12 (PH0), Y1.3
unnamed: C8.2, U1.13 (PH1), Y1.1
unnamed: L2.1, U4.5 (SW)
RAW: C16.2, D1.1 (K), Q1.2 (S), U4.1 (Vin), U4.3 (EN)
VBUS: L3.2, Q1.3 (D), U1.68 (PA9)
VCC: C3.1, C4.1, C5.1, C6.1, C9.1, C13.2, C15.1, C17.2, C18.1, C19.1, D2.2 (A), J1.4 (VDD), J3.9, J4.19, J4.23, J4.28, L1.2, L2.2, R6.2, R7.2, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN2.1 (R1.1), RN2.2 (R2.1), RN2.3 (R3.1), RN2.4 (R4.1), U1.6 (VBAT), U1.11 (VDD), U1.27 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U2.1 (V_{IN}), U2.3 (CE), U4.4 (FB)
VDDA: C14.2, J4.20, J4.21, U2.5 (V_{OUT})
VIN: D1.2 (A), J3.10, Q1.1 (G), R3.2

Notes on the sheet:
Notes: Y{9:2} for 8-bit YUV or RGB <Y9 MSB, Y2 LSB> DVDD nit connected, using internal regulator
VIN:外接入独立供电 case 1：PMOS OPEN,RAW=VIN case 0：PMOS CLOSE,RAW=VBUS

Board: 6 copper layers, 26.0 x 26.0 mm, 40 parts (20 on the bottom side), 64 nets.

## KiCad design #8. ESP32S3MINI BOARD/esp32-s3-DevKit.kicad_pcb

Board: 2 copper layers, 25.4 x 62.7 mm, 48 parts (2 on the bottom side), 58 nets.

Parts:
C1, C7: 1uF/16V(10%); C_0603_1608Metric
C2, C4, C5, C8, C10: 10uF/25V(20%); C_0603_1608Metric
C3: NC_10uF/25V(20%); C_0603_1608Metric
C6, C9, C11, C12, C13: 0.1uF/50V(10%); C_0603_1608Metric
D1, D2, D4, D6, D7, D8: LESD5D5.0CT1G; D_SOD-523
D3, D5: 1N5819WS; D_SOD-323
D9: SK6812MINI-HS; LED_WS2812B-Mini_PLCC4_3.5x3.5mm
D10: RED LED; D_0603_1608Metric
J1: ESP USB; USB_Micro-B_Molex-105017-0001
J2: USB TO UART; USB_Micro-B_Molex-105017-0001
J3, J4: Conn_01x22; PinHeader_1x22_P2.54mm_Vertical
Q1, Q2: L8050QLT1G; 1B2E3C_SOT-23
R1: 22.1K(1%); R_0603_1608Metric
R2: 47.5K(1%); R_0603_1608Metric
R3: 1K(1%); R_0603_1608Metric
R4, R5, R7, R9, R12, R13: 0; R_0603_1608Metric
R6: NC_10K(1%); R_0603_1608Metric
R8, R10, R11: 10K(1%); R_0603_1608Metric
R14: 5.1K; R_0603_1608Metric
SW1, SW2: TS-1088R-02026
U1: CP2102N-Axx-xQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm
U2: ESP32-S3-WROOM-1
U3: SGM2212-3.3XKC3G/TR; SOT-223-3_TabPin2

Connections:
/CHIP_PU: C7.1, C12.1, J3.3, R8.1, R12.2, SW1.2, U2.3 (EN)
/D+: D8.2 (A2), J2.3 (D+), U1.4 (D+)
/D-: D6.2 (A2), J2.2 (D-), U1.5 (D-)
/DTR: Q2.3 (E), R10.2, U1.28 (~DTR)
/GPIO0: C13.1, J4.14, R13.2, SW2.2, U2.27 (IO0)
/GPIO1: J4.4, U2.39 (IO1)
/GPIO2: J4.5, U2.38 (IO2)
/GPIO3: J3.13, U2.15 (IO3)
/GPIO4: J3.4, U2.4 (IO4)
/GPIO5: J3.5, U2.5 (IO5)
/GPIO6: J3.6, U2.6 (IO6)
/GPIO7: J3.7, U2.7 (IO7)
/GPIO8: J3.12, U2.12 (IO8)
/GPIO9: J3.15, U2.17 (IO9)
/GPIO10: J3.16, U2.18 (IO10)
/GPIO11: J3.17, U2.19 (IO11)
/GPIO12: J3.18, U2.20 (IO12)
/GPIO13: J3.19, U2.21 (IO13)
/GPIO14: J3.20, U2.22 (IO14)
/GPIO15: J3.8, U2.8 (IO15)
/GPIO16: J3.9, U2.9 (IO16)
/GPIO17: J3.10, U2.10 (IO17)
/GPIO18: J3.11, U2.11 (IO18)
/GPIO19: D4.2 (A2), J1.2 (D-), J4.20, U2.13 (IO19)
/GPIO20: D7.2 (A2), J1.3 (D+), J4.19, U2.14 (IO20)
/GPIO21: J4.18, U2.23 (IO21)
/GPIO35: J4.13, U2.28 (IO35)
/GPIO36: J4.12, U2.29 (IO36)
/GPIO37: J4.11, U2.30 (IO37)
/GPIO38: J4.10, R9.1, U2.31 (IO38)
/GPIO39: J4.9, U2.32 (IO39)
/GPIO40: J4.8, U2.33 (IO40)
/GPIO41: J4.7, U2.34 (IO41)
/GPIO42: J4.6, U2.35 (IO42)
/GPIO45: J4.15, U2.26 (IO45)
/GPIO46: J3.14, U2.16 (IO46)
/GPIO47: J4.17, U2.24 (IO47)
/GPIO48: J4.16, U2.25 (IO48)
/RGB_CTRL: D9.2 (DIN), R9.2
/RTS: Q1.3 (E), R11.2, U1.24 (~RTS)
/U0RXD: J4.3, R4.2, U2.36 (RXD0)
/U0TXD: J4.2, R5.2, U2.37 (TXD0)
ESP_3V3: J3.1, J3.2, R7.2, R8.2, U2.2 (3V3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.1 (A1), D2.1 (A1), D4.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (VSS), D10.1 (K), J1.5 (GND), J1.6 (Shield), J2.5 (GND), J2.6 (Shield), J3.22, J4.1, J4.21, J4.22, R2.2, R6.2, SW1.1, SW2.1, U1.3 (GND), U1.29 (GND), U2.1 (GND), U2.40 (GND), U2.41 (GND), U3.1 (GND)
unnamed: D10.2 (A), R14.2
unnamed: Q1.2 (B), R10.1
unnamed: Q1.1 (C), R12.1
unnamed: Q2.2 (B), R11.1
unnamed: Q2.1 (C), R13.1
unnamed: R5.1, U1.25 (RXD)
unnamed: R4.1, U1.26 (TXD)
unnamed: C1.1, R1.2, R2.1, U1.8 (VBUS)
unnamed: R3.1, U1.9 (~RST)
unnamed: R6.1, U1.11 (~SUSPEND)
VBUS: D2.2 (A2), D5.2 (A), J2.1 (VBUS), R1.1
VBUSB: D1.2 (A2), D3.2 (A), J1.1 (VBUS)
VCC_3V3: C2.1, C5.1, C6.1, C10.1, C11.1, D9.3 (VDD), R3.2, R7.1, R14.1, U1.6 (VDD), U1.7 (VREGIN), U3.2 (VO)
VCC_5V: C3.1, C4.1, C8.1, C9.1, D3.1 (K), D5.1 (K), J3.21, U3.3 (VI)
